SUMMARY = "Packagegroup including esme-gpio-toggle"
DESCRIPTION = "This packagegroup installs esme-gpio-toggle"
LICENSE = "CLOSED"

RDEPENDS_${PN} = "esme-gpio-toggle"
